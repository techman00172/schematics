** sch_path: mousetrap.sch
**.subckt mousetrap
Q1 net2 net3 net1 Q2N2907 area=1 m=1
V1 net1 net4 24
**.ends
.end
